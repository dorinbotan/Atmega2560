.ORG 0x0
JMP MAIN

.ORG 0x16
JMP TO_OV_ISR

.ORG 0x100
MAIN:
LDI R20, HIGH(RAMEND)
OUT SPH, R20
LDI R20, LOW(RAMEND)
OUT SPL, R20

SBI DDRB, 5
LDI R20, 0x00
OUT DDRC, R20
LDI R20, 0xFF
OUT DDRD, R20

LDI R20, (1<<TOIE0)
STS TIMSK0, R20
SEI

LDI R20, 0
OUT TCNT0, R20
LDI R20, 0b00000101
OUT TCCR0B, R20

HERE:
IN R20, PINC
OUT PORTD, R20
JMP HERE

.ORG 0x200
TO_OV_ISR:
IN R16, PORTB
LDI R17, 0x20
EOR R16, R17
OUT PORTB, R16
LDI R16, -32
OUT TCNT0, R16
RETI