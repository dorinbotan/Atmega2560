.ORG 0x00
RJMP MAIN

.ORG 0x02
RJMP EX0_ISR

.ORG 0x04
RJMP EX0_ISR

.ORG 0x06
RJMP EX0_ISR

.ORG 0x08
RJMP EX0_ISR

MAIN:
LDI R16, HIGH(RAMEND)
OUT SPH, R16
LDI R16, LOW(RAMEND) 
OUT SPL, R16

LDI R16, 0xFF
OUT DDRC, R16
COM R16
OUT DDRD, R16
out PORTD, R16
OUT PORTC, R16

LDI R16, 0b01000000
SEI PCINT0
OUT ISC, R16
SEI

HERE:
RJMP HERE

EX0_ISR:
IN R16, PINC
COM R16
OUT PORTC, R16
RETI